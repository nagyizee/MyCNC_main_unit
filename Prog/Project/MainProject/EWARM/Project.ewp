# IAR project Project.ewp, settings and files
configuration CAMHEAD_RAM (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100x6 ST STM32F100x6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_LD_VL; VECT_TAB_SRAM; USE_GLIB_ON_EWARM
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\..\..\000_SoftOnly\MyGraphicLibrary\MyGraphicLibrary\graphic_lib_app\graphic_lib; ..\hw; ..\func
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f10x_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CAMHEAD_FLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD_VL; USE_GLIB_ON_EWARM
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h
    ../: system_stm32f10x.c
  group Doc
    ./: readme.txt
  group StartUp
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md_vl.s
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../: main.c mainapp.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h typedefs.h
  group User/func
    ../func/: core.c core.h dispHAL.c dispHAL.h dispHAL_internal.h eeprom_spi.c eeprom_spi.h events_ui.c events_ui.h ui.c ui.h ui_elements.c ui_elements.h ui_graphics.c ui_graphics.h ui_internals.h
  group User/graphic_lib
    ../../../../../../000_SoftOnly/MyGraphicLibrary/MyGraphicLibrary/graphic_lib_app/graphic_lib/: graphic_lib.c graphic_lib.h
  group User/hw
    ../hw/: hw_stuff.c hw_stuff.h stdlib_extension.c stdlib_extension.h
